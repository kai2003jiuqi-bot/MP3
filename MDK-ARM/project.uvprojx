# Keil uVision project project.uvprojx, settings and files
target project (ARM-ADS)
  device: ARMCM4 ARM
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ..\Core\Inc;..\FATFS\Target;..\FATFS\App;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Middlewares\Third_Party\FatFs\src;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\CMSIS\Include;..\.cmsis\include;RTE\_project;..\lvgl;..\lvgl\lvgl\src;..\lvgl\lvgl\src\core;..\lvgl\lvgl\src\draw;..\lvgl\lvgl\src\extra;..\lvgl\lvgl\src\font;..\lvgl\lvgl\src\hal;..\lvgl\lvgl\src\misc;..\lvgl\lvgl\src\widgets;..\User\App\inc;..\User\BSP\ili9341_driver;..\User\Middlewares\lvgl_port;..\User\Middlewares\File;..\User\Middlewares\TCHAR_String;..\User\Middlewares\BootCount;..\User\BSP\vs1003;..\User\Middlewares\RX_StateMachine;..\User\BSP\Key;..\User\BSP\w25q64;..\User\Middlewares\UI;..\User\Middlewares\JPEGDEC;..\USB_DEVICE\App;..\USB_DEVICE\Target;..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;..\User\Middlewares\tjpgd
  asm include: ../Core/Inc;../FATFS/Target;../FATFS/App;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Lvgl/lvgl/src/widgets
    ../Lvgl/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Lvgl/lvgl/src/misc
    ../Lvgl/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Lvgl/lvgl/src/hal
    ../Lvgl/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Lvgl/lvgl/src/font
    ../Lvgl/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group Lvgl/lvgl/src/extra
    ../Lvgl/lvgl/src/extra/: lv_extra.c
  group Lvgl/lvgl/src/extra/widgets/win
    ../Lvgl/lvgl/src/extra/widgets/win/: lv_win.c
  group Lvgl/lvgl/src/extra/widgets/tileview
    ../Lvgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c
  group Lvgl/lvgl/src/extra/widgets/tabview
    ../Lvgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c
  group Lvgl/lvgl/src/extra/widgets/spinner
    ../Lvgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c
  group Lvgl/lvgl/src/extra/widgets/spinbox
    ../Lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
  group Lvgl/lvgl/src/extra/widgets/span
    ../Lvgl/lvgl/src/extra/widgets/span/: lv_span.c
  group Lvgl/lvgl/src/extra/widgets/msgbox
    ../Lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
  group Lvgl/lvgl/src/extra/widgets/meter
    ../Lvgl/lvgl/src/extra/widgets/meter/: lv_meter.c
  group Lvgl/lvgl/src/extra/widgets/menu
    ../Lvgl/lvgl/src/extra/widgets/menu/: lv_menu.c
  group Lvgl/lvgl/src/extra/widgets/list
    ../Lvgl/lvgl/src/extra/widgets/list/: lv_list.c
  group Lvgl/lvgl/src/extra/widgets/led
    ../Lvgl/lvgl/src/extra/widgets/led/: lv_led.c
  group Lvgl/lvgl/src/extra/widgets/keyboard
    ../Lvgl/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
  group Lvgl/lvgl/src/extra/widgets/imgbtn
    ../Lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
  group Lvgl/lvgl/src/extra/widgets/colorwheel
    ../Lvgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
  group Lvgl/lvgl/src/extra/widgets/chart
    ../Lvgl/lvgl/src/extra/widgets/chart/: lv_chart.c
  group Lvgl/lvgl/src/extra/widgets/calendar
    ../Lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
  group Lvgl/lvgl/src/extra/widgets/animimg
    ../Lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c
  group Lvgl/lvgl/src/extra/themes/mono
    ../Lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c
  group Lvgl/lvgl/src/extra/themes/default
    ../Lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c
  group Lvgl/lvgl/src/extra/themes/basic
    ../Lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c
  group Lvgl/lvgl/src/extra/others/snapshot
    ../Lvgl/lvgl/src/extra/others/snapshot/: lv_snapshot.c
  group Lvgl/lvgl/src/extra/others/msg
    ../Lvgl/lvgl/src/extra/others/msg/: lv_msg.c
  group Lvgl/lvgl/src/extra/others/monkey
    ../Lvgl/lvgl/src/extra/others/monkey/: lv_monkey.c
  group Lvgl/lvgl/src/extra/others/imgfont
    ../Lvgl/lvgl/src/extra/others/imgfont/: lv_imgfont.c
  group Lvgl/lvgl/src/extra/others/ime
    ../Lvgl/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
  group Lvgl/lvgl/src/extra/others/gridnav
    ../Lvgl/lvgl/src/extra/others/gridnav/: lv_gridnav.c
  group Lvgl/lvgl/src/extra/others/fragment
    ../Lvgl/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
  group Lvgl/lvgl/src/extra/libs/tiny_ttf
    ../Lvgl/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
  group Lvgl/lvgl/src/extra/libs/sjpg
    ../Lvgl/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
  group Lvgl/lvgl/src/extra/libs/rlottie
    ../Lvgl/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
  group Lvgl/lvgl/src/extra/libs/qrcode
    ../Lvgl/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
  group Lvgl/lvgl/src/extra/libs/png
    ../Lvgl/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
  group Lvgl/lvgl/src/extra/libs/gif
    ../Lvgl/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
  group Lvgl/lvgl/src/extra/libs/fsdrv
    ../Lvgl/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
  group Lvgl/lvgl/src/extra/libs/freetype
    ../Lvgl/lvgl/src/extra/libs/freetype/: lv_freetype.c
  group Lvgl/lvgl/src/extra/libs/ffmpeg
    ../Lvgl/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
  group Lvgl/lvgl/src/extra/libs/bmp
    ../Lvgl/lvgl/src/extra/libs/bmp/: lv_bmp.c
  group Lvgl/lvgl/src/extra/layouts/grid
    ../Lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c
  group Lvgl/lvgl/src/extra/layouts/flex
    ../Lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c
  group Lvgl/lvgl/src/draw
    ../Lvgl/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group Lvgl/lvgl/src/draw/swm341_dma2d
    ../Lvgl/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
  group Lvgl/lvgl/src/draw/sw
    ../Lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group Lvgl/lvgl/src/draw/stm32_dma2d
    ../Lvgl/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group Lvgl/lvgl/src/draw/sdl
    ../Lvgl/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
  group Lvgl/lvgl/src/draw/renesas
    ../Lvgl/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
  group Lvgl/lvgl/src/draw/nxp/vglite
    ../Lvgl/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
  group Lvgl/lvgl/src/draw/nxp/pxp
    ../Lvgl/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
  group Lvgl/lvgl/src/draw/arm2d
    ../Lvgl/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
  group Lvgl/lvgl/src/core
    ../Lvgl/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group User/Middlewares/UI
    ../User/Middlewares/UI/: ui.c
  group User/Middlewares/tjpgd
    ../User/Middlewares/tjpgd/: tjpgd.c
  group User/Middlewares/TCHAR_String
    ../User/Middlewares/TCHAR_String/: TCHAR_Sring.c
  group User/Middlewares/RX_StateMachine
    ../User/Middlewares/RX_StateMachine/: rx_stateMachine.c
  group User/Middlewares/lvgl_port
    ../User/Middlewares/lvgl_port/: lv_port_disp.c lv_port_indev.c my_font.c my_font_song_14.c
  group User/Middlewares/JPEGDEC
    ../User/Middlewares/JPEGDEC/: cover_jpegdec.c cover_tjpgd.c
  group User/Middlewares/File
    ../User/Middlewares/File/: file.c
  group User/Middlewares/BootCount
    ../User/Middlewares/BootCount/: bootCount.c
  group User/BSP/w25q64
    ../User/BSP/w25q64/: w25q64.c
  group User/BSP/vs1003
    ../User/BSP/vs1003/: vs1003.c
  group User/BSP/Key
    ../User/BSP/Key/: Key.c
  group User/BSP/ili9341_driver
    ../User/BSP/ili9341_driver/: ili9341_display.c ili9341_touch.c
  group User/App/src
    ../User/App/src/: app_main.c task_key.c task_lvgl.c task_playMusic.c task_uart.c task_usbDevice.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_storage_if.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c user_diskio.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c sdio.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group User/App/src
    ../User/App/src/: app_main.c task_key.c task_lvgl.c task_playMusic.c task_uart.c app_main.c task_key.c task_lvgl.c task_playMusic.c task_uart.c ui.c
  group User/BSP/ili9341_driver
    ../User/BSP/ili9341_driver/: ili9341_display.c ili9341_touch.c ili9341_display.c ili9341_touch.c
  group User/BSP/Key
    ../User/BSP/Key/: Key.c Key.c
  group User/BSP/vs1003
    ../User/BSP/vs1003/: vs1003.c vs1003.c
  group User/BSP/w25q64
    ../User/BSP/w25q64/: w25q64.c
  group User/Middlewares/BootCount
    ../User/Middlewares/BootCount/: bootCount.c bootCount.c
  group User/Middlewares/File
    ../User/Middlewares/File/: file.c file.c
  group User/Middlewares/lvgl_port
    ../User/Middlewares/lvgl_port/: lv_port_disp.c lv_port_indev.c my_font.c my_font_song_14.c lv_port_disp.c lv_port_indev.c my_font.c
  group User/Middlewares/RX_StateMachine
    ../User/Middlewares/RX_StateMachine/: rx_stateMachine.c rx_stateMachine.c
  group User/Middlewares/TCHAR_String
    ../User/Middlewares/TCHAR_String/: TCHAR_Sring.c TCHAR_Sring.c
  group User/Middlewares/UI
    ../User/Middlewares/UI/: ui.c
  group Lvgl/lvgl/src/core
    ../Lvgl/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Lvgl/lvgl/src/draw
    ../Lvgl/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group Lvgl/lvgl/src/draw/arm2d
    ../Lvgl/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c lv_gpu_arm2d.c
  group Lvgl/lvgl/src/draw/nxp/pxp
    ../Lvgl/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
  group Lvgl/lvgl/src/draw/nxp/vglite
    ../Lvgl/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
  group Lvgl/lvgl/src/draw/renesas
    ../Lvgl/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
  group Lvgl/lvgl/src/draw/sdl
    ../Lvgl/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
  group Lvgl/lvgl/src/draw/stm32_dma2d
    ../Lvgl/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c lv_gpu_stm32_dma2d.c
  group Lvgl/lvgl/src/draw/sw
    ../Lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group Lvgl/lvgl/src/draw/swm341_dma2d
    ../Lvgl/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c lv_gpu_swm341_dma2d.c
  group Lvgl/lvgl/src/extra
    ../Lvgl/lvgl/src/extra/: lv_extra.c lv_extra.c
  group Lvgl/lvgl/src/extra/layouts/flex
    ../Lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c lv_flex.c
  group Lvgl/lvgl/src/extra/layouts/grid
    ../Lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c lv_grid.c
  group Lvgl/lvgl/src/extra/libs/bmp
    ../Lvgl/lvgl/src/extra/libs/bmp/: lv_bmp.c lv_bmp.c
  group Lvgl/lvgl/src/extra/libs/ffmpeg
    ../Lvgl/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.c
  group Lvgl/lvgl/src/extra/libs/freetype
    ../Lvgl/lvgl/src/extra/libs/freetype/: lv_freetype.c lv_freetype.c
  group Lvgl/lvgl/src/extra/libs/fsdrv
    ../Lvgl/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
  group Lvgl/lvgl/src/extra/libs/gif
    ../Lvgl/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c gifdec.c lv_gif.c
  group Lvgl/lvgl/src/extra/libs/png
    ../Lvgl/lvgl/src/extra/libs/png/: lodepng.c lv_png.c lodepng.c lv_png.c
  group Lvgl/lvgl/src/extra/libs/qrcode
    ../Lvgl/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c lv_qrcode.c qrcodegen.c
  group Lvgl/lvgl/src/extra/libs/rlottie
    ../Lvgl/lvgl/src/extra/libs/rlottie/: lv_rlottie.c lv_rlottie.c
  group Lvgl/lvgl/src/extra/libs/sjpg
    ../Lvgl/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c lv_sjpg.c tjpgd.c
  group Lvgl/lvgl/src/extra/libs/tiny_ttf
    ../Lvgl/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c lv_tiny_ttf.c
  group Lvgl/lvgl/src/extra/others/fragment
    ../Lvgl/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c lv_fragment.c lv_fragment_manager.c
  group Lvgl/lvgl/src/extra/others/gridnav
    ../Lvgl/lvgl/src/extra/others/gridnav/: lv_gridnav.c lv_gridnav.c
  group Lvgl/lvgl/src/extra/others/ime
    ../Lvgl/lvgl/src/extra/others/ime/: lv_ime_pinyin.c lv_ime_pinyin.c
  group Lvgl/lvgl/src/extra/others/imgfont
    ../Lvgl/lvgl/src/extra/others/imgfont/: lv_imgfont.c lv_imgfont.c
  group Lvgl/lvgl/src/extra/others/monkey
    ../Lvgl/lvgl/src/extra/others/monkey/: lv_monkey.c lv_monkey.c
  group Lvgl/lvgl/src/extra/others/msg
    ../Lvgl/lvgl/src/extra/others/msg/: lv_msg.c lv_msg.c
  group Lvgl/lvgl/src/extra/others/snapshot
    ../Lvgl/lvgl/src/extra/others/snapshot/: lv_snapshot.c lv_snapshot.c
  group Lvgl/lvgl/src/extra/themes/basic
    ../Lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c lv_theme_basic.c
  group Lvgl/lvgl/src/extra/themes/default
    ../Lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c lv_theme_default.c
  group Lvgl/lvgl/src/extra/themes/mono
    ../Lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c lv_theme_mono.c
  group Lvgl/lvgl/src/extra/widgets/animimg
    ../Lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c lv_animimg.c
  group Lvgl/lvgl/src/extra/widgets/calendar
    ../Lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
  group Lvgl/lvgl/src/extra/widgets/chart
    ../Lvgl/lvgl/src/extra/widgets/chart/: lv_chart.c lv_chart.c
  group Lvgl/lvgl/src/extra/widgets/colorwheel
    ../Lvgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c lv_colorwheel.c
  group Lvgl/lvgl/src/extra/widgets/imgbtn
    ../Lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c lv_imgbtn.c
  group Lvgl/lvgl/src/extra/widgets/keyboard
    ../Lvgl/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c lv_keyboard.c
  group Lvgl/lvgl/src/extra/widgets/led
    ../Lvgl/lvgl/src/extra/widgets/led/: lv_led.c lv_led.c
  group Lvgl/lvgl/src/extra/widgets/list
    ../Lvgl/lvgl/src/extra/widgets/list/: lv_list.c lv_list.c
  group Lvgl/lvgl/src/extra/widgets/menu
    ../Lvgl/lvgl/src/extra/widgets/menu/: lv_menu.c lv_menu.c
  group Lvgl/lvgl/src/extra/widgets/meter
    ../Lvgl/lvgl/src/extra/widgets/meter/: lv_meter.c lv_meter.c
  group Lvgl/lvgl/src/extra/widgets/msgbox
    ../Lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c lv_msgbox.c
  group Lvgl/lvgl/src/extra/widgets/span
    ../Lvgl/lvgl/src/extra/widgets/span/: lv_span.c lv_span.c
  group Lvgl/lvgl/src/extra/widgets/spinbox
    ../Lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c lv_spinbox.c
  group Lvgl/lvgl/src/extra/widgets/spinner
    ../Lvgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c lv_spinner.c
  group Lvgl/lvgl/src/extra/widgets/tabview
    ../Lvgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c lv_tabview.c
  group Lvgl/lvgl/src/extra/widgets/tileview
    ../Lvgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c lv_tileview.c
  group Lvgl/lvgl/src/extra/widgets/win
    ../Lvgl/lvgl/src/extra/widgets/win/: lv_win.c lv_win.c
  group Lvgl/lvgl/src/font
    ../Lvgl/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group Lvgl/lvgl/src/hal
    ../Lvgl/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Lvgl/lvgl/src/misc
    ../Lvgl/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Lvgl/lvgl/src/widgets
    ../Lvgl/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
software components: CMSIS:CORE 4.3.0
